# Keil uVision project Minibalance.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Minibalance +hex
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\OLED;..\HARDWARE\ADC;..\HARDWARE\TIMER;..\HARDWARE\MOTOR;..\BALANCE\CONTROL;..\HARDWARE\ENCODER;..\HARDWARE\IIC;..\BALANCE\CONTROL;..\BALANCE\DMP;..\BALANCE\filter;..\BALANCE\MPU6050;..\BALANCE\show;..\BALANCE\controls;..\HARDWARE\EXTI;..\HARDWARE\DataScope_DP;..\HARDWARE\CAN;..\HARDWARE\STMFLASH;..\HARDWARE\USARTX;..\USER;..\HARDWARE\PS2;..\HARDWARE
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Source Group 1
    ./: startup_stm32f10x_hd.s
  group USER
    ./: Minibalance.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/USARTX/: usartx.c
    ../HARDWARE/LED/: LED.C
    ../HARDWARE/ENCODER/: encoder.c
    ../HARDWARE/IIC/: IOI2C.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/MOTOR/: motor.c
    ../HARDWARE/: chaosheng.c HMC5883L.c
  group BALANCE
    ../BALANCE/show/: show.c
    ../BALANCE/DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../BALANCE/MPU6050/: MPU6050.c
    ../BALANCE/CONTROL/: control.c
